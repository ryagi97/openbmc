# use SmartCow fork
SRC_URI = "git://git@smartcow.dev:/SmartCow/openbmc-webui-vue.git;branch=kirkstone;protocol=ssh"
SRCREV = "bf9310d98fe659754a9ae213cadf21c9bf3b259f"