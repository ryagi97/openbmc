FILESEXTRAPATHS:prepend:beagleboneblack := "${THISDIR}/${PN}:"
